Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_UC_UC075WJ_INT-EN.ifc
Time: 2025-08-05T18:26:30+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_1991194_1 | SINK
OutPort_1991194_2 | SOURCE

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_UC_INT-EN:UC075WJ, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_UC_INT-EN:UC075WJ:1991194
In: F00
Type - Material: Color RGB 168-128-048, Color RGB 055-055-055
Type - Other - Category: Pipe Accessories; Connection Diameter: 19.05 mm; Diameter Safe 1: 36.95 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_UC_INT-EN; h: 123 mm; h1: 149 mm; Height Safe 1: 15.95 mm; Left Clearance Safe: 0 mm; Left Pipe Radius: 25 mm; Minimum Bottom Clearance: 100 mm; Minimum Top Clearance: 75 mm; Nominal Diameter: 19.05 mm; Nut Height Safe: 13 mm; Outer Diameter: 26.9 mm; Radius Safe 1: 15 mm; Radius Safe 2: 14.475 mm; Radius Safe 3: 14.723 mm; Radius Safe 4: 16 mm; Radius Safe 5: 13.475 mm; Radius Safe 6: 9.525 mm; Right Clearance Safe: 116.525 mm; Upper Pipe Height: 72.5 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - a: 0 mm; b: 125 mm; d: 19.05 mm; H: 272 mm; Height Safe 2: 25 mm; L: 100 mm; Left Cutout Angle: 134 deg; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Brass 3/4" - Magnet; Article Type: UC075WJ; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Brass 3/4" - Magnet; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811049051; Manufacturer: Spirotech; Manufacturer Art. No.: UC075WJ; Manufacturer URL: https://www.spirotech.com/8717811049051; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: UC075WJ; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: UC075WJ; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Dark Yellow: Color RGB 168-128-048
Type - Mechanical - Capacity: 0; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.00036 m3/s; Pressure Stage: 10; Volume: 0.00053 m3; Weight: 2.41 kg
Type - Mechanical - Flow - Pressure Drop: 2100 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: UC075WJ; sets with these values: 2
Other - Bottom Clearance Safe: 100 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_UC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_UC_INT-EN: UC075WJ; Top Clearance Safe: 75 mm; Type: UC075WJ; Type Id: 1991169
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.120848 m2; Maximum Size: 19.05 mm; Minimum Size: 19.05 mm; Volume: 0.00114917 m3
Graphics - Annotation Offset RL: 0 mm; Use Annotation Scale: no
Identity Data - Mark: 11
Mechanical - Flow 1: 0 m3/s; Flow 2: 0 m3/s; System Classification: Undefined
Mechanical - Flow - Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 100 mm; Service Space: no; Top Clearance: 75 mm
Insulation - Insulation Thickness: 0 mm
